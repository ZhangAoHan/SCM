# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD
  c include: ..\HARDWARE\IIC;..\HARDWARE\OLED;..\MPU6050\DMP;..\MPU6050\MPU6050;..\SYSTEM\delay;..\SYSTEM\usart;..\MPU6050\IIC;..\SYSTEM\sys;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: README.TXT
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/IIC/: iic.c
  group MPU6050
    ../MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../MPU6050/IIC/: IOI2C.c
    ../MPU6050/MPU6050/: MPU6050.c
