# Keil uVision project LED.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\Motor;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\Oled;..\HARDWARE\MPU6050\DMP;..\HARDWARE\MPU6050\MPU6050;..\HARDWARE\MPU6050\IIC;..\HARDWARE\Control
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/Motor/: Motor.c
    ../HARDWARE/Oled/: Oled.c
    ../HARDWARE/MPU6050/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/MPU6050/IIC/: IOI2C.c
    ../HARDWARE/MPU6050/MPU6050/: MPU6050.c
    ../HARDWARE/Control/: Timer.c Control.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c
  group README
    ../: README.TXT
